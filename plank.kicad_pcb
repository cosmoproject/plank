# Repository cosmoproject/plank

## KiCad design plank.kicad_pcb

Parts:
C1, C2, C4, C5, C6, C7, C8, C9, C10, C11, C12, C14, C15, C16, C17, C18, C19, C20, C21: C; C_0603
C13: CP; C_Radial_D5_L11_P2.5
D1, D2, D4, D5, D7, D8, D9, D10, D11, D12, D13, D14, D16, D17, D18, D19, D20, D21, D22, D23: ZENER; SOD-523
D3: RED FAULT; LED_0603
D6: GREEN PWR; LED_0603
D15: BLUE TEST; LED_0603
F1: FUSE; C_1206_HandSoldering
P1: 3.3V; Pin_Header_Straight_1x02
P2: I2C; Pin_Header_Straight_1x04
P3: SW0; Pin_Header_Straight_1x02
P4: SW1; Pin_Header_Straight_1x02
P5: SW2; Pin_Header_Straight_1x02
P6: SW3; Pin_Header_Straight_1x02
P7: LED0; Pin_Header_Straight_1x02
P8: ANA0; Potentiometer_WirePads
P9: ANA4; Potentiometer_WirePads
P10: SW4; Pin_Header_Straight_1x02
P11: LED1; Pin_Header_Straight_1x02
P12: ANA1; Potentiometer_WirePads
P13: ANA5; Potentiometer_WirePads
P14: SW5; Pin_Header_Straight_1x02
P15: LED2; Pin_Header_Straight_1x02
P16: ANA2; Potentiometer_WirePads
P17: ANA6; Potentiometer_WirePads
P18: SW6; Pin_Header_Straight_1x02
P19: LED3; Pin_Header_Straight_1x02
P20: SW7; Pin_Header_Straight_1x02
P21: LED4; Pin_Header_Straight_1x02
P22: ANA3; Potentiometer_WirePads
P23: ANA7; Potentiometer_WirePads
P24: LED5; Pin_Header_Straight_1x02
P25: LED6; Pin_Header_Straight_1x02
P26: LED7; Pin_Header_Straight_1x02
P27: CONN_01X05; Pin_Header_Straight_1x05
R1, R3, R4: 100; R_0603
R2, R25, R26, R27, R28, R29, R30, R31, R32: 10k; R_0603
R5: 180; R_0603
R6: 150; R_0603
R7: R; R_0603
R8, R9, R10, R11, R12, R13, R14, R15: R; Resistor_Horizontal_RM10mm
R16, R17, R18, R19, R20, R21, R22, R23: 1k; R_0603
R33, R34: DNM; R_0603
U1: MAX7313; SSOP-24_3.9x8.7mm_Pitch0.635mm
U2: MCP3008; SOIC-16_3.9x9.9mm_Pitch1.27mm

Connections:
+3V3: C1.1, C2.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, D1.1 (K), F1.2, P7.2, P8.3, P9.3, P11.2, P12.3, P13.3, P15.2, P16.3, P17.3, P19.2, P21.2, P22.3, P23.3, P24.2, P25.2, P26.2, R2.1, R5.2, R7.1, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, U1.24 (V+), U2.15, U2.16
/MISO: P27.3, U2.12
/MOSI: P27.4, U2.11
/ana0: C14.1, R20.1, U2.1
/ana1: C16.1, R16.1, U2.2
/ana2: C18.1, R21.1, U2.3
/ana3: C20.1, R17.1, U2.4
/ana4: C15.1, R22.1, U2.5
/ana5: C17.1, R18.1, U2.6
/ana6: C19.1, R23.1, U2.7
/ana7: C21.1, R19.1, U2.8
/scl: D4.1 (K), R3.1, R33.1, U1.22 (SCL)
/sda: D5.1 (K), R1.1, R34.1, U1.23 (SDA)
/spiclk: P27.2, U2.13
/~CS: P27.5, U2.10
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D1.2 (A), D2.2 (A), D4.2 (A), D5.2 (A), D6.1 (K), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), P1.1, P2.2, P3.1, P4.1, P5.1, P6.1, P8.1, P9.1, P10.1, P12.1, P13.1, P14.1, P16.1, P17.1, P18.1, P20.1, P22.1, P23.1, P27.1, R6.1, U1.2 (AD1), U1.3 (AD2), U1.12 (GND), U1.21 (AD0), U2.9, U2.14
unnamed: D2.1 (K), R4.1, U1.1 (~INT)
unnamed: D3.1 (K), R6.2
unnamed 18: D3.2 (A); also elsewhere on the board
unnamed: D6.2 (A), R5.1
unnamed: D8.1 (K), R9.2, U1.14 (P9)
unnamed: D9.1 (K), R10.2, U1.15 (P10)
unnamed: D10.1 (K), R11.2, U1.16 (P11)
unnamed: D11.1 (K), R12.2, U1.17 (P12)
unnamed: D12.1 (K), R13.2, U1.18 (P13)
unnamed: D13.1 (K), R14.2, U1.19 (P14)
unnamed: D14.1 (K), R15.2, U1.20 (P15)
unnamed: D7.1 (K), D15.1 (K), R8.2, U1.13 (P8)
unnamed: D15.2 (A), R7.2
unnamed: D16.1 (K), P4.2, R26.1, U1.5 (P1)
unnamed: D17.1 (K), P6.2, R28.1, U1.7 (P3)
unnamed: D18.1 (K), P14.2, R30.1, U1.9 (P5)
unnamed: D19.1 (K), P20.2, R32.1, U1.11 (P7)
unnamed: D20.1 (K), P3.2, R25.1, U1.4 (P0)
unnamed: D21.1 (K), P5.2, R27.1, U1.6 (P2)
unnamed: D22.1 (K), P10.2, R29.1, U1.8 (P4)
unnamed: D23.1 (K), P18.2, R31.1, U1.10 (P6)
unnamed 37: F1.1, P1.2; also elsewhere on the board
unnamed: P2.1, R4.2
unnamed: P2.3, R3.2
unnamed: P2.4, R1.2
unnamed: P7.1, R8.1
unnamed: P8.2, R20.2
unnamed: P9.2, R22.2
unnamed: P11.1, R9.1
unnamed: P12.2, R16.2
unnamed: P13.2, R18.2
unnamed: P15.1, R10.1
unnamed: P16.2, R21.2
unnamed: P17.2, R23.2
unnamed: P19.1, R11.1
unnamed: P21.1, R12.1
unnamed: P22.2, R17.2
unnamed: P23.2, R19.2
unnamed: P24.1, R13.1
unnamed: P25.1, R14.1
unnamed: P26.1, R15.1
unnamed 57: R2.2; also elsewhere on the board

Notes on the sheet:
addr: 0100000

Board: 2 copper layers, 148.6 x 24.1 mm, 107 parts (32 on the bottom side), 58 nets.

Other parts of the board:
Q1: Q_PNP_BEC; SOT-23

Their connections:
unnamed 18: Q1.3; also elsewhere on the board
unnamed 37: Q1.2; also elsewhere on the board
unnamed 57: Q1.1; also elsewhere on the board

## Commit log

2016-10-23 Dump before changing to mcp3008
2016-10-24 Taped out 20 cards
2017-01-22 New version of the plank
2017-01-22 Render PCB and schematic
2018-06-20 Add latest fab
